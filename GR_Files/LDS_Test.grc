options:
  parameters:
    author: MR
    generate_options: qt_gui
    id: LDS_Test
    output_language: python
    title: LDS Test
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(samp_rate)
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: QAM.bin
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: ./Data_Files/MFSK.bin
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: ./Data_Files/LDSO.bin
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: ./Data_Files/LDS.bin
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0_0_0_0
  id: blocks_file_source
  parameters:
    file: ./Data_Files/QAM.bin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.6'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: fc
    dev_addr: '"serial=3279417"'
    dev_args: '""'
    gain0: '40'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: fc
    dc_offs_enb0: '""'
    dev_addr: '"serial=3279500"'
    dev_args: '""'
    gain0: '30'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_delay_0, '0', blocks_throttle_0, '0']
- [blocks_delay_0, '0', uhd_usrp_sink_0, '0']
- [blocks_file_source_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_file_source_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_file_source_0_0_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_delay_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
